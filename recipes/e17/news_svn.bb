LICENSE = "MIT"
PV = "0.1.0+svnr${SRCPV}"

require e-module.inc

do_configure_prepend() {
	autopoint
}



